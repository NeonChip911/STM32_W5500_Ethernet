# Keil uVision project EthernetCommunication.uvprojx, settings and files
target EthernetCommunication (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: EthernetCommunication +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../../MyCEPMaterial/W550_STM32_P1/W550_STM32_P1/Drivers/Ethernet_W550;../../MyCEPMaterial/W550_STM32_P1/W550_STM32_P1/Drivers/Ethernet_W550/W5500;../../MyCEPMaterial/ioLibrary_Driver-master/ioLibrary_Driver-master/Ethernet/W5500;../W550_STM32_P5/W550_STM32_P5/Drivers/Ethernet_W550;../W550_STM32_P5/W550_STM32_P5/Drivers/Ethernet_W550/DHCP;../W550_STM32_P6/W550_STM32_P6/Drivers/Ethernet_W550;../W550_STM32_P6/W550_STM32_P6/Drivers/Ethernet_W550/httpServer;../W550_STM32_P6/W550_STM32_P6/Core/Inc;../W550_STM32_P6/W550_STM32_P6/Core/Src;../../MyCEPMaterial/I2C-LCD-STM32-master/I2C-LCD-STM32-master;..\..\My CEP Material\HCSR04_PWidth_F103\HCSR04_PWidth_F103\Core\Inc;../../MyCEPMaterial/HCSR04_PWidth_F103/HCSR04_PWidth_F103/Core/Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
    ../W550_STM32_P6/W550_STM32_P6/Core/Src/: BME280_STM32.c
  group Application/User/Core
    ../W550_STM32_P6/W550_STM32_P6/Core/Inc/: BME280_STM32.h
    ../../My CEP Material/HCSR04_PWidth_F103/HCSR04_PWidth_F103/Core/Src/: i2c-lcd.c
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
    ../../My CEP Material/HCSR04_PWidth_F103/HCSR04_PWidth_F103/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_i2c.c
  group Drivers/CMSIS
    ../../My CEP Material/W550_STM32_P1/W550_STM32_P1/Drivers/Ethernet_W550/: socket.c socket.h wizchip_conf.c wizchip_conf.h wizchip_port.c wizchip_port.h
    ../../My CEP Material/W550_STM32_P1/W550_STM32_P1/Drivers/Ethernet_W550/W5500/: w5500.c w5500.h
    ../../My CEP Material/W550_STM32_P1/W550_STM32_P1/Drivers/Ethernet_W550/DNS/: dns.c dns.h
    ../../My CEP Material/ioLibrary_Driver-master/ioLibrary_Driver-master/Internet/httpServer/: httpParser.c httpParser.h httpServer.h httpUtil.c httpUtil.h
    ../W550_STM32_P5/W550_STM32_P5/Drivers/Ethernet_W550/DHCP/: dhcp.c dhcp.h
    ../W550_STM32_P6/W550_STM32_P6/Drivers/Ethernet_W550/: http_server_example.c http_server_example.h
    ../W550_STM32_P6/W550_STM32_P6/Drivers/Ethernet_W550/httpServer/: httpServer.c
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 6.2.0
